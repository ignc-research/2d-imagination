Commit message: eval paper

File: simulator_setup/robot/thisrobot.urdf.xacro (robot description, xacro)
@@ -17,5 +17,5 @@
     <visual>
       <geometry>
-        <sphere radius="0.2"/>
+        <sphere radius="0.1"/>
       </geometry>
     </visual>
